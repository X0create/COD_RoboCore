# Keil uVision project dm_mc02.uvprojx, settings and files
target dm_mc02 (6220000::V6.22::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: COD_RoboCore
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: DEBUG,STM32H723xx,USE_HAL_DRIVER,USE_PWR_LDO_SUPPLY,RTT_USE_ASM=0
  c include: ..\..\..;..\Core\Inc;..\USB_DEVICE\App;..\USB_DEVICE\Target;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\Drivers\CMSIS\RTOS2\Include;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Drivers\CMSIS\Include;..\Middlewares\ST\ARM\DSP\Inc;..\..\..\04_core\log\segger_rtt;..\..\..\04_core\log
  asm include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: ..\dm_mc02.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c bdma.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group 01_applic/config
    ../../../01_applic/config/: robot.c
  group 01_applic/modules/chassis
    ../../../01_applic/modules/chassis/: chassis.c
  group 01_applic/modules/ins
    ../../../01_applic/modules/ins/: ins.c
  group 01_applic/system
    ../../../01_applic/system/: app_main.c safety_gate.c
  group 01_applic/tasks
    ../../../01_applic/tasks/: comm_rx_task.c control_task.c detect_task.c indicator_task.c ins_task.c log_task.c
  group 02_devices/battery
    ../../../02_devices/battery/: battery.c
  group 02_devices/board_link
    ../../../02_devices/board_link/: board_link.c
  group 02_devices/buzzer
    ../../../02_devices/buzzer/: buzzer.c
  group 02_devices/imu
    ../../../02_devices/imu/: bmi088.c
  group 02_devices/motor
    ../../../02_devices/motor/: motor.c
  group 02_devices/referee
    ../../../02_devices/referee/: referee_frame.c
  group 02_devices/remote
    ../../../02_devices/remote/: dr16.c vt_link.c
  group 02_devices/vision
    ../../../02_devices/vision/: vision.c
  group 03_algorithm/attitude
    ../../../03_algorithm/attitude/: attitude.c
  group 03_algorithm/control
    ../../../03_algorithm/control/: control.c
  group 03_algorithm/filter
    ../../../03_algorithm/filter/: filter.c
  group 03_algorithm/kinematics
    ../../../03_algorithm/kinematics/: kinematics.c
  group 03_algorithm/math
    ../../../03_algorithm/math/: rm_math.c
  group 03_algorithm/power
    ../../../03_algorithm/power/: rls.c
  group 04_core/log
    ../../../04_core/log/: log.c
  group 04_core/log/segger_rtt
    ../../../04_core/log/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group 04_core/os
    ../../../04_core/os/: os.c
  group 04_core/util
    ../../../04_core/util/: crc.c
  group 04_core/watchdog
    ../../../04_core/watchdog/: watchdog.c
  group 05_platform/adc
    ../../../05_platform/adc/: adc_stm32h7.c
  group 05_platform/can
    ../../../05_platform/can/: can.c can_stm32h7.c
  group 05_platform/pwm
    ../../../05_platform/pwm/: pwm_stm32h7.c
  group 05_platform/spi
    ../../../05_platform/spi/: spi_stm32h7.c
  group 05_platform/status_led
    ../../../05_platform/status_led/: status_led.c status_led_stm32h7.c
  group 05_platform/time
    ../../../05_platform/time/: time.c time_stm32h7.c
  group 05_platform/uart
    ../../../05_platform/uart/: uart.c uart_stm32h7.c
  group 05_platform/usb_cdc
    ../../../05_platform/usb_cdc/: usb_cdc.c usb_cdc_stm32h7.c
software components: CMSIS:CORE 4.3.0
